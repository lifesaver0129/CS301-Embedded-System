# Keil uVision project 11510225.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 11510225
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\HARDWARE\LED;.\SYSTEM\delay;.\SYSTEM\sys;.\UCOSII\CONFIG;.\UCOSII\CORE;.\UCOSII\PORT;.\RTE;.\RTE\Device\STM32F103RC;.\SYSTEM\usart
  asm include: .\SYSTEM\delay;.\HARDWARE\LED;.\SYSTEM\sys;.\UCOSII\CONFIG
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Source Group 1
    ./: main.c
    ./HARDWARE/LED/: led.c
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/usart/: usart.c
  group CORE
    ./UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group PORT
    ./UCOSII/PORT/: os_cpu_a.asm os_cpu_c.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
