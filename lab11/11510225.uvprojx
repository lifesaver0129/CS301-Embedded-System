# Keil uVision project 11510225.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 11510225
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\HARDWARE\LED;.\HARDWARE\REMOTE;.\HARDWARE\LCD;.\SYSTEM\usart;.\SYSTEM\delay;.\SYSTEM\sys;.\RTE;.\RTE\Device\STM32F103RC;.\HARDWARE\KEY
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Source Group 1
    ./: main.c
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/usart/: usart.c
    ./HARDWARE/LCD/: lcd.c
    ./HARDWARE/LED/: led.c
    ./HARDWARE/REMOTE/: remote.c
    ./HARDWARE/KEY/: key.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
